## Assigment4/Assigment4_fifo/build_nrf52840dk_nrf52840/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "D:/Programs_Repository/Nordic_ide/v1.9.1/nrf/boards/shields/*/Kconfig.defconfig"
```
